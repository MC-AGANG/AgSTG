#include "AgSTG.h"
using namespace AgSTG;
uint16_t Texture_PlayerBullet_d[]={0x7E0, 0x7E0, 0x7E0, 0xD01F, 0xD01F, 0x7E0, 0x7E0, 0x7E0, 0x7E0, 0x7E0, 0x7E0, 0xD01F, 0xD01F, 0x7E0, 0x7E0, 0x7E0, 0x7E0, 0x7E0, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0x7E0, 0x7E0, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0x7E0, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0x7E0, 0x7E0, 0x7E0, 0xD01F, 0xD01F, 0xD01F, 0xD01F, 0x7E0, 0x7E0, 0x7E0, 0xD01F, 0xD01F, 0x7E0, 0x7E0, 0xD01F, 0xD01F, 0x7E0, 0xD01F, 0xD01F, 0x7E0, 0x7E0, 0x7E0, 0x7E0, 0xD01F, 0xD01F, };
Bitmap Texture_PlayerBullet = Bitmap(8,8,Texture_PlayerBullet_d);
PlayerBullet::PlayerBullet(double x,double y){
  X=x;
  Y=y;
  Height=8;
  Width=8;
  Type=2;
  HitboxSize=5;
  Texture=&Texture_PlayerBullet;
  Speed=6;
  Direction=0;
}
void PlayerBullet::Loop(){
  Move();
  for(int i=0;i<1024;i++){
    if(STG.Objects[i]!=nullptr&&STG.Objects[i]->Type==3){
      if(Judge(STG.Objects[i])){
        static_cast<Enemy*>(STG.Objects[i])->Damage(4);
        Clear();
      }
    }
  }
}